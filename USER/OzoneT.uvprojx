# Keil uVision project OzoneT.uvprojx, settings and files
target UCOSII-1-2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OzoneT +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\HARDWARE\TPAD;..\HARDWARE\AT24C64_Driver;..\HARDWARE\ADC;..\HARDWARE\Basic_Lib;..\HARDWARE\HIM_LCD;.\app;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\HARDWARE\SysIO_Init;..\HARDWARE\TIMER;..\HARDWARE\MP3;..\HARDWARE\NTC
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./app/: adc_task.c common.c common.h ctr_task.c Function.c Led_test.c Lcd_Test.c test.h
    ../HARDWARE/HIM_LCD/: him_lcd.h
    ../UCOSII/CONFIG/: includes.h
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/AT24C64_Driver/: AT24C64_Driver.c
    ../HARDWARE/HIM_LCD/: HMI_Driver.c USART3_Driver.c HMI_Driver_T5.h HMI_Driver_T5.c
    ../HARDWARE/Basic_Lib/: Basic_Lib.c
    ../HARDWARE/SysIO_Init/: SysIO_Init.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/MP3/: USART2_Driver.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/NTC/: NTC.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_dma.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu_a.asm os_cpu_c.c os_cpu.h
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group README
    ../: Readme.c
